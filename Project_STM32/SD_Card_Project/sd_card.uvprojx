# Keil uVision project sd_card.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sd_card +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xx
  c include: D:\Thesis_IoT\Library_STM32F4\en.stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;D:\Thesis_IoT\Library_STM32F4\en.stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\src;D:\Thesis_IoT\Library_STM32F4\en.stm32f4_dsp_stdperiph_lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\SD_Card;D:\Thesis_IoT\00_FreeRTOS\Source_code\FreeRTOSv10.2.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;D:\Thesis_IoT\00_FreeRTOS\Source_code\FreeRTOSv10.2.1\FreeRTOS\Source\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Code
    ./: spi_if.c main.c list.c timers.c
  group Header file
    ./: spi_if.h
  group Library
    D:/Thesis_IoT/Library_STM32F4/en.stm32f4_dsp_stdperiph_lib/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_rcc.c stm32f4xx_tim.c
    D:/Thesis_IoT/Library_STM32F4/en.stm32f4_dsp_stdperiph_lib/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_spi.h
    D:/Thesis_IoT/Library_STM32F4/en.stm32f4_dsp_stdperiph_lib/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./: stm32f4xx_conf.h
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 2.6.2
